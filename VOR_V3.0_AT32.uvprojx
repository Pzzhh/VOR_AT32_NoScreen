# Keil uVision project VOR_V3.0_AT32.uvprojx, settings and files
target develop (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F435ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 7_pwm_output +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=1.bin !L
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1,ATM32F43_xx,Task_ARY_MAX=15
  c include: .\libraries\drivers\inc;.\inc;.\libraries\cmsis\cm4\core_support;.\libraries\cmsis\cm4\device_support;.\middleLib\freertos\source\include;.\middleLib\freertos\source\portable\memmang;.\middleLib\freertos\source\portable\rvds\ARM_CM4F;.\cfg;.\HARDWARE\SYSTEM\delay;.\HARDWARE\LCD;.\HARDWARE\TOUCH;.\INTERFACE\LVGL\lvgl;.\INTERFACE\LVGL\lvgl\lsrc;.\INTERFACE\LVGL\lvgl\src\core;.\INTERFACE\LVGL\lvgl\src\draw;.\INTERFACE\LVGL\lvgl\src\font;.\INTERFACE\LVGL\lvgl\src\hal;.\INTERFACE\LVGL\lvgl\src\misc;.\INTERFACE\LVGL\lvgl\src\theme;.\INTERFACE\LVGL\lvgl\src\widgets;.\INTERFACE\LVGL\lvgl\src\extra;.\INTERFACE\LVGL\lvgl\src\extra\layouts;.\INTERFACE\LVGL\lvgl\src\extra\layout\flex;.\INTERFACE\LVGL\lv_port;.\INTERFACE\LVGL\lvgl\src\extra\layouts\flex;.\INTERFACE\LVGL\lvgl\src\extra\layouts\grid;.\INTERFACE\LVGL\lvgl\src\extra\libs;.\INTERFACE\LVGL\lvgl\src\extra\others;.\INTERFACE\LVGL\lvgl\src\extra\themes;.\INTERFACE\LVGL\lvgl\src\extra\widgets;.\INTERFACE\LVGL\lvgl\src\extra\themes\basic;.\INTERFACE\LVGL\lvgl\src\extra\libs\qrcode;.\HARDWARE\SYSTEM\sys;.\HARDWARE\SYSTEM\delay;.\HARDWARE\SYSTEM\usart;.\INTERFACE\LVGL;.\INTERFACE\UI;.\INTERFACE\UI\control;.\HARDWARE\TOUCH;..\VOR_V2.0\HARDWARE\c610;.\commuication\USB;.\commuication\USB\usb_drivers\inc;.\commuication\USB\usbd_class\cdc
  memory RVCT4: ROM 0x8001000 size 0xa0000
  memory RVCT5: ROM 0x8201000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x5fff0
  group user
    ./src/: at32f435_437_clock.c at32f435_437_int.c main.c at32f435_437_board.c
    ./cfg/: include_port.c
  group HARDWARE
    HARDWARE/LCD/: lcd.c
    HARDWARE/TOUCH/: ft5206.c ctiic.c
    HARDWARE/SLAVE/: Slave1_IO.c Slave1_Timer.c
    HARDWARE/USART/: USART1.c USART3.c USART5.c USART6.c
    HARDWARE/CAN/: can.c
    HARDWARE/IR_Sense/: IR.c
    HARDWARE/INC/: INC_CTRl.c
    HARDWARE/FAN/: FAN.c
    HARDWARE/c610/: C610.c pid.c
    ./HARDWARE/TOUCH/: gt9147.c
    ./HARDWARE/IO/: GPIO.c
    ./HARDWARE/RNG/: RNG.c
    ./HARDWARE/RTC/: rtc.c
    ./HARDWARE/EROM/: eriic.c
    ./HARDWARE/Motor/: inc_motor.c
  group SYSTEM
    ./HARDWARE/SYSTEM/delay/: delay.c
    ./HARDWARE/SYSTEM/sys/: sys.c
  group lib
    ./libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group cmsis
    ./libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ./libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group freertos
    ./middleLib/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./middleLib/freertos/source/portable/memmang/: heap_4.c
  group lv_port
    ./INTERFACE/LVGL/lv_port/: lv_port_disp.c lv_port_indev.c
  group lv_core
    ./INTERFACE/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lv_draw
    ./INTERFACE/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./INTERFACE/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_transform.c lv_draw_sw_layer.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lv_extra
    ./INTERFACE/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./INTERFACE/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./INTERFACE/LVGL/lvgl/src/extra/: lv_extra.c
    ./INTERFACE/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./INTERFACE/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ./INTERFACE/LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./INTERFACE/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group lv_font
    ./INTERFACE/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_hal
    ./INTERFACE/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ./INTERFACE/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_widgets
    ./INTERFACE/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ./INTERFACE/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
  group control
    ./INTERFACE/UI/control/: control.c control_base.c task_control.c control_Hardware_API.c control_CONT.h control_VOR.c control_CONT.c control_OVAR.c control_VHIT.c control_TC.c control_ZERO.c
  group other
    ./INTERFACE/UI/other/: list.c system_function.c meassage_center.c
  group Task_Manager
    ./INTERFACE/UI/Task/: task_stroage.c task_manager.c
  group UI_Component
    ./INTERFACE/UI/UI_Component/: UI_Btn.c UI_Dropdown.c UI_ListBox.c UI_SpinBox.c UI_KeyBorad.c
  group UI_page
    ./INTERFACE/UI/UI_page/: page1.c PageManagment.c Page_Maintain.c Page_Varify.c Page_Outage_Event.c
  group UI_parameter
    ./INTERFACE/UI/UI_Parameter/: UI_Parameter_Cont.c UI_Parameter_Vor.c UI_Parameter_Ovar.c UI_Parameter_Set.c UI_Parameter_VHIT.c UI_Parameter_TC.c
  group implement
    ./implement/: Slave_Vor_Ctrl.c Slave_OVAR_Ctrl.c Slave_Cont_Ctrl.c Slave_Inc_Ctrl.c motor_para_cal.c Slave_VHIT_Ctrl.c Slave_TC_Ctrl.c Slave_Zero_ctrl.c
  group varify
    ./INTERFACE/UI/varify/: verfiy.c
  group communication
    ./commuication/BLUETOOTH/: BlueTooth.c
    ./commuication/: communication.c communication_API.c rk3588_uart.c usb_control_base.c usb_vor_control.c
    ./commuication/mpu/: jy60.c
  group usb
    ./commuication/USB/usbd_class/cdc/: cdc_class.c cdc_desc.c
    ./commuication/USB/: usb_init.c usb_conf.h
    ./commuication/USB/usb_drivers/src/: usbd_int.c usbd_sdr.c usbd_core.c usb_core.c
